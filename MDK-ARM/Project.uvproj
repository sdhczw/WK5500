# Keil uVision project Project.uvproj, settings and files
target Multi Media Development Board V1.0 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: ZC_MODULE_VERSION=0 ZC_MODULE_TYPE=20 ZC_MODULE_DEV
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\SysTick;..\include;..\include\APPs;..\include\W5500;..\USER\APPs\ZC\inc\aes;..\USER\APPs\ZC\inc\tropicssl;..\USER\APPs\ZC\inc\zc;..\USER\APPs\AC\inc;..\USER\APPs\ADAPTOR;..\USER\APPs\Internet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h led.c
    ../USER/SysTick/: stm32f10x_systick.c systick.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../: readme.txt
  group W5500
    ../USER/: util.c
    ../USER/W5500/: md5.c socket.c w5500.c SPI2.c
  group ZC
    ../USER/APPs/ZC/src/zc/: zc_bc.c zc_client_manager.c zc_cloud_event.c zc_common.c zc_configuration.c zc_message_queue.c zc_moudle_manager.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c
    ../USER/APPs/ZC/src/tropicssl/: bignum.c rsa.c
    ../USER/APPs/ZC/src/crc/: crc.c
    ../USER/APPs/ZC/src/aes/: aes_cbc.c aes_core.c
  group Adapter
    ../USER/APPs/ADAPTOR/: zc_adapter.c
  group AC
    ../USER/APPs/AC/src/: ac_api.c ac_hal.c
  group Internet
    ../USER/APPs/Internet/: dhcp.c dns.c
